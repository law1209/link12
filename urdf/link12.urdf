Commit message: More clear

File: urdf/link12.urdf (robot description, URDF)
Before this commit: robot link12, 4 links, 3 joints
Links:
- link base_link: mass 1.5532 -> 3
- link link1: mass 1.3945 -> 2
- link link2: mass 2.5669 -> 1
